v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
P 4 1 -720 540 {}
P 4 2 -791.25 473.75 -791.25 473.75 {}
N -1870 370 -1360 370 {lab=#net1}
N -1237.5 370 -1100 370 {lab=#net2}
N -1060 400 -1060 690 {lab=#net3}
N -1870 720 -1100 720 {lab=#net4}
N -1540 540 -1440 540 {lab=#net1}
N -1440 540 -1420 540 {lab=#net1}
N -1420 370 -1420 540 {lab=#net1}
N -1540 590 -1420 590 {lab=#net4}
N -1420 590 -1420 720 {lab=#net4}
N -2230 370 -2070 370 {lab=#net5}
N -2230 370 -2230 720 {lab=#net5}
N -2230 720 -2070 720 {lab=#net5}
N -2230 560 -1730 560 {lab=#net5}
N -2370 322.5 -2370 430 {lab=VDD}
N -2370 430 -2070 430 {lab=VDD}
N -2370 430 -2370 780 {lab=VDD}
N -2370 780 -2070 780 {lab=VDD}
N -1060 550 -940 550 {lab=#net3}
N -1060 322.5 -1060 340 {lab=VDD}
N -1060 370 -1047.5 370 {lab=VDD}
N -1047.5 370 -1045 370 {lab=VDD}
N -1045 332.5 -1045 370 {lab=VDD}
N -1060 332.5 -1045 332.5 {lab=VDD}
N -1060 750 -1060 765 {lab=GND}
N -1060 720 -1047.5 720 {lab=GND}
N -1047.5 720 -1047.5 757.5 {lab=GND}
N -1060 757.5 -1047.5 757.5 {lab=GND}
N 1120 1100 1160 1100 {lab=VCO}
N 3456.25 -480 3456.25 -220 {lab=#net6}
N 2771.25 -480 3456.25 -480 {lab=#net6}
N 2771.25 -510 2771.25 -480 {lab=#net6}
N 3216.25 -440 3216.25 -220 {lab=#net7}
N 2731.25 -440 3216.25 -440 {lab=#net7}
N 2731.25 -510 2731.25 -440 {lab=#net7}
N 2996.25 -400 2996.25 -220 {lab=#net8}
N 2691.25 -400 2996.25 -400 {lab=#net8}
N 2691.25 -510 2691.25 -400 {lab=#net8}
N 2786.25 -360 2786.25 -220 {lab=#net9}
N 2651.25 -360 2786.25 -360 {lab=#net9}
N 2651.25 -510 2651.25 -360 {lab=#net9}
N 1936.25 -480 1936.25 -220 {lab=#net10}
N 1936.25 -480 2491.25 -480 {lab=#net10}
N 2491.25 -510 2491.25 -480 {lab=#net10}
N 2166.25 -440 2166.25 -220 {lab=#net11}
N 2166.25 -440 2531.25 -440 {lab=#net11}
N 2531.25 -510 2531.25 -440 {lab=#net11}
N 2376.25 -400 2376.25 -220 {lab=#net12}
N 2376.25 -400 2571.25 -400 {lab=#net12}
N 2571.25 -510 2571.25 -400 {lab=#net12}
N 2576.25 -360 2576.25 -220 {lab=#net13}
N 2576.25 -360 2611.25 -360 {lab=#net13}
N 2611.25 -510 2611.25 -360 {lab=#net13}
N 1906.25 -10 1906.25 825 {lab=#net14}
N 1986.25 45 1986.25 825 {lab=#net15}
N 1986.25 45 2136.25 45 {lab=#net15}
N 2136.25 -10 2136.25 45 {lab=#net15}
N 2066.25 80 2066.25 825 {lab=#net16}
N 2066.25 80 2346.25 80 {lab=#net16}
N 2346.25 -10 2346.25 80 {lab=#net16}
N 2146.25 125 2146.25 825 {lab=#net17}
N 2146.25 120 2146.25 125 {lab=#net17}
N 2146.25 120 2546.25 120 {lab=#net17}
N 2546.25 -10 2546.25 120 {lab=#net17}
N 2226.25 160 2226.25 825 {lab=#net18}
N 2226.25 160 2756.25 160 {lab=#net18}
N 2756.25 -10 2756.25 160 {lab=#net18}
N 2306.25 200 2306.25 825 {lab=#net19}
N 2306.25 200 2966.25 200 {lab=#net19}
N 2966.25 -10 2966.25 200 {lab=#net19}
N 2386.25 235 2386.25 825 {lab=#net20}
N 2386.25 235 3186.25 235 {lab=#net20}
N 3186.25 -10 3186.25 235 {lab=#net20}
N 2466.25 260 2466.25 825 {lab=#net21}
N 2466.25 260 3426.25 260 {lab=#net21}
N 3426.25 -10 3426.25 260 {lab=#net21}
N 3311.25 360 3311.25 885 {lab=n0}
N 1966.25 360 3311.25 360 {lab=n0}
N 1966.25 -10 1966.25 360 {lab=n0}
N 3351.25 385 3351.25 885 {lab=n1}
N 2196.25 385 3351.25 385 {lab=n1}
N 2196.25 -10 2196.25 385 {lab=n1}
N 3391.25 405 3391.25 885 {lab=n2}
N 2406.25 405 3391.25 405 {lab=n2}
N 2406.25 -10 2406.25 405 {lab=n2}
N 3431.25 425 3431.25 885 {lab=n3}
N 2606.25 425 3431.25 425 {lab=n3}
N 2606.25 -10 2606.25 425 {lab=n3}
N 3471.25 445 3471.25 885 {lab=n4}
N 2816.25 445 3471.25 445 {lab=n4}
N 2816.25 -10 2816.25 445 {lab=n4}
N 3511.25 465 3511.25 885 {lab=n5}
N 3026.25 465 3511.25 465 {lab=n5}
N 3026.25 -10 3026.25 465 {lab=n5}
N 3551.25 485 3551.25 885 {lab=n6}
N 3246.25 485 3551.25 485 {lab=n6}
N 3246.25 -10 3246.25 485 {lab=n6}
N 3596.25 505 3596.25 885 {lab=n7}
N 3486.25 505 3596.25 505 {lab=n7}
N 3486.25 -10 3486.25 505 {lab=n7}
N 2631.25 -1025 2631.25 -977.5 {lab=#net22}
N 2631.25 -1165 2631.25 -1148.75 {lab=FD}
N 2631.25 -1192.5 2631.25 -1165 {lab=FD}
N 1471.25 -1192.5 2631.25 -1192.5 {lab=FD}
N 1471.25 -1192.5 1471.25 120 {lab=FD}
N 1471.25 243.75 1471.25 365 {lab=#net23}
N 1471.25 488.75 1471.25 600 {lab=#net24}
N 1471.25 723.75 1471.25 1502.5 {lab=#net25}
N 1471.25 1502.5 2346.25 1502.5 {lab=#net25}
N 2346.25 1345 2346.25 1502.5 {lab=#net25}
N 2631.25 -1218.75 2631.25 -1192.5 {lab=FD}
N -940 550 -740 550 {lab=#net3}
N -680 550 -420 550 {lab=Vcon}
N -420 550 -400 550 {lab=Vcon}
N 1966.25 1345 1966.25 1420 {lab=Out}
N -3000 750 -2070 750 {lab=FD}
N -3000 -1660 2631.25 -1660 {lab=FD}
N 2631.25 -1660 2631.25 -1218.75 {lab=FD}
N -620 550 -620 590 {lab=Vcon}
N -3000 -1660 -3000 750 {lab=FD}
N 965 867.5 1095 867.5 {lab=VCO}
N 965 867.5 965 1100 {lab=VCO}
N 965 1100 990 1100 {lab=VCO}
N 1080 1550 1080 1580 {lab=VDD}
N 1240 1550 1240 1580 {lab=VDD}
N 1080 1610 1110 1610 {lab=VDD}
N 1110 1550 1110 1610 {lab=VDD}
N 1240 1610 1270 1610 {lab=VDD}
N 1080 1780 1240 1780 {lab=GND}
N 1080 1750 1110 1750 {lab=GND}
N 1110 1750 1110 1780 {lab=GND}
N 1240 1750 1260 1750 {lab=GND}
N 1260 1750 1260 1780 {lab=GND}
N 1180 1610 1200 1610 {lab=#net26}
N 1180 1610 1180 1750 {lab=#net26}
N 1180 1750 1200 1750 {lab=#net26}
N 1020 1610 1040 1610 {lab=VCO}
N 1020 1610 1020 1750 {lab=VCO}
N 1020 1750 1040 1750 {lab=VCO}
N 1080 1640 1080 1720 {lab=#net26}
N 1240 1640 1240 1720 {lab=Out}
N 1240 1680 1330 1680 {lab=Out}
N 1080 1680 1180 1680 {lab=#net26}
N 980 1680 1020 1680 {lab=VCO}
N 943.75 1680 980 1680 {lab=VCO}
N 943.75 1243.75 943.75 1680 {lab=VCO}
N 943.75 1243.75 1210 1243.75 {lab=VCO}
N 1210 1100 1210 1243.75 {lab=VCO}
N 1160 1100 1210 1100 {lab=VCO}
N 1966.25 1420 2100 1420 {lab=Out}
N 2100 1420 2270 1420 {lab=Out}
N 2440 1680 2510 1680 {lab=Out}
N 2510 1420 2510 1680 {lab=Out}
N 2270 1420 2510 1420 {lab=Out}
N 2430 1680 2440 1680 {lab=Out}
N 1930 1680 2430 1680 {lab=Out}
N 1270 1610 1280 1610 {lab=VDD}
N 1280 1550 1280 1610 {lab=VDD}
N 1080 1550 1280 1550 {lab=VDD}
N 1180 1530 1180 1550 {lab=VDD}
N 1240 1780 1260 1780 {lab=GND}
N 1330 1680 1930 1680 {lab=Out}
N 1176.25 1780 1177.5 1780 {lab=GND}
N 1176.25 1780 1176.25 1806.25 {lab=GND}
N 1210 1240 1220 1240 {lab=VCO}
N 990 1100 1122.5 1100 {lab=VCO}
N 105 2.5 105 82.5 {lab=#net27}
N 105 142.5 105 240 {lab=#net28}
N 105 300 105 360 {lab=#net29}
N 105 420 105 452.5 {lab=GND}
N 105 -87.5 105 -57.5 {lab=VDD}
N 105 -27.5 155 -27.5 {lab=VDD}
N 155 -67.5 155 -27.5 {lab=VDD}
N 105 -67.5 155 -67.5 {lab=VDD}
N 105 112.5 155 112.5 {lab=VDD}
N 155 -27.5 155 112.5 {lab=VDD}
N 105 390 165 390 {lab=GND}
N 105 442.5 165 442.5 {lab=GND}
N 105 270 165 270 {lab=GND}
N 165 390 165 442.5 {lab=GND}
N 165 272.5 165 390 {lab=GND}
N 165 270 165 272.5 {lab=GND}
N 40 112.5 65 112.5 {lab=VCO}
N 40 112.5 40 267.5 {lab=VCO}
N 40 267.5 40 270 {lab=VCO}
N 40 270 65 270 {lab=VCO}
N -5 -27.5 65 -27.5 {lab=#net30}
N -2.5 390 65 390 {lab=Vcon}
N 325 2.5 325 82.5 {lab=#net31}
N 325 142.5 325 240 {lab=#net32}
N 325 300 325 360 {lab=#net33}
N 325 420 325 452.5 {lab=GND}
N 325 -87.5 325 -57.5 {lab=VDD}
N 325 -27.5 375 -27.5 {lab=VDD}
N 375 -67.5 375 -27.5 {lab=VDD}
N 325 -67.5 375 -67.5 {lab=VDD}
N 325 112.5 375 112.5 {lab=VDD}
N 375 -27.5 375 112.5 {lab=VDD}
N 325 390 385 390 {lab=GND}
N 325 442.5 385 442.5 {lab=GND}
N 325 270 385 270 {lab=GND}
N 385 390 385 442.5 {lab=GND}
N 385 272.5 385 390 {lab=GND}
N 385 270 385 272.5 {lab=GND}
N 260 112.5 285 112.5 {lab=#net28}
N 260 112.5 260 267.5 {lab=#net28}
N 260 267.5 260 270 {lab=#net28}
N 260 270 285 270 {lab=#net28}
N 215 -27.5 285 -27.5 {lab=#net30}
N 217.5 390 285 390 {lab=Vcon}
N 545 2.5 545 82.5 {lab=#net34}
N 545 142.5 545 240 {lab=#net35}
N 545 300 545 360 {lab=#net36}
N 545 420 545 452.5 {lab=GND}
N 545 -87.5 545 -57.5 {lab=VDD}
N 545 -27.5 595 -27.5 {lab=VDD}
N 595 -67.5 595 -27.5 {lab=VDD}
N 545 -67.5 595 -67.5 {lab=VDD}
N 545 112.5 595 112.5 {lab=VDD}
N 595 -27.5 595 112.5 {lab=VDD}
N 545 390 605 390 {lab=GND}
N 545 442.5 605 442.5 {lab=GND}
N 545 270 605 270 {lab=GND}
N 605 390 605 442.5 {lab=GND}
N 605 272.5 605 390 {lab=GND}
N 605 270 605 272.5 {lab=GND}
N 480 112.5 505 112.5 {lab=#net32}
N 480 112.5 480 267.5 {lab=#net32}
N 480 267.5 480 270 {lab=#net32}
N 480 270 505 270 {lab=#net32}
N 435 -27.5 505 -27.5 {lab=#net30}
N 437.5 390 505 390 {lab=Vcon}
N 755 2.5 755 82.5 {lab=#net37}
N 755 142.5 755 240 {lab=#net38}
N 755 300 755 360 {lab=#net39}
N 755 420 755 452.5 {lab=GND}
N 755 -87.5 755 -57.5 {lab=VDD}
N 755 -27.5 805 -27.5 {lab=VDD}
N 805 -67.5 805 -27.5 {lab=VDD}
N 755 -67.5 805 -67.5 {lab=VDD}
N 755 112.5 805 112.5 {lab=VDD}
N 805 -27.5 805 112.5 {lab=VDD}
N 755 390 815 390 {lab=GND}
N 755 442.5 815 442.5 {lab=GND}
N 755 270 815 270 {lab=GND}
N 815 390 815 442.5 {lab=GND}
N 815 272.5 815 390 {lab=GND}
N 815 270 815 272.5 {lab=GND}
N 690 112.5 715 112.5 {lab=#net35}
N 690 112.5 690 267.5 {lab=#net35}
N 690 267.5 690 270 {lab=#net35}
N 690 270 715 270 {lab=#net35}
N 645 -27.5 715 -27.5 {lab=#net30}
N 647.5 390 715 390 {lab=Vcon}
N 975 2.5 975 82.5 {lab=#net40}
N 975 142.5 975 240 {lab=VCO}
N 975 300 975 360 {lab=#net41}
N 975 420 975 452.5 {lab=GND}
N 975 -87.5 975 -57.5 {lab=VDD}
N 975 -27.5 1025 -27.5 {lab=VDD}
N 1025 -67.5 1025 -27.5 {lab=VDD}
N 975 -67.5 1025 -67.5 {lab=VDD}
N 975 112.5 1025 112.5 {lab=VDD}
N 1025 -27.5 1025 112.5 {lab=VDD}
N 975 390 1035 390 {lab=GND}
N 975 442.5 1035 442.5 {lab=GND}
N 975 270 1035 270 {lab=GND}
N 1035 390 1035 442.5 {lab=GND}
N 1035 272.5 1035 390 {lab=GND}
N 1035 270 1035 272.5 {lab=GND}
N 975 192.5 1095 192.5 {lab=VCO}
N 910 112.5 935 112.5 {lab=#net38}
N 910 112.5 910 267.5 {lab=#net38}
N 910 267.5 910 270 {lab=#net38}
N 910 270 935 270 {lab=#net38}
N 865 -27.5 935 -27.5 {lab=#net30}
N 867.5 390 935 390 {lab=Vcon}
N -85 2.5 -85 172.5 {lab=#net30}
N -195 -27.5 -125 -27.5 {lab=#net30}
N -85 -27.5 -65 -27.5 {lab=VDD}
N -65 -57.5 -65 -27.5 {lab=VDD}
N -85 -57.5 -65 -57.5 {lab=VDD}
N -85 392.5 -65 392.5 {lab=GND}
N -65 392.5 -65 422.5 {lab=GND}
N -85 422.5 -65 422.5 {lab=GND}
N -85 172.5 -85 362.5 {lab=#net30}
N 755 192.5 910 192.5 {lab=#net38}
N 545 192.5 690 192.5 {lab=#net35}
N 325 192.5 480 192.5 {lab=#net32}
N 105 192.5 260 192.5 {lab=#net28}
N 1095 -167.5 1095 192.5 {lab=VCO}
N -290 -167.5 1095 -167.5 {lab=VCO}
N -290 -167.5 -290 192.5 {lab=VCO}
N -290 192.5 40 192.5 {lab=VCO}
N -195 57.5 -85 57.5 {lab=#net30}
N -195 -27.5 -195 57.5 {lab=#net30}
N -195 -212.5 -195 -27.5 {lab=#net30}
N -195 -212.5 865 -212.5 {lab=#net30}
N 865 -212.5 865 -27.5 {lab=#net30}
N 645 -212.5 645 -27.5 {lab=#net30}
N 435 -212.5 435 -27.5 {lab=#net30}
N 215 -212.5 215 -27.5 {lab=#net30}
N -5 -212.5 -5 -27.5 {lab=#net30}
N 865 390 867.5 390 {lab=Vcon}
N 865 390 865 502.5 {lab=Vcon}
N -315 502.5 865 502.5 {lab=Vcon}
N -315 392.5 -315 502.5 {lab=Vcon}
N -315 392.5 -125 392.5 {lab=Vcon}
N -2.5 390 -2.5 502.5 {lab=Vcon}
N 215 390 217.5 390 {lab=Vcon}
N 215 390 215 502.5 {lab=Vcon}
N 435 390 437.5 390 {lab=Vcon}
N 435 390 435 502.5 {lab=Vcon}
N 647.5 390 647.5 502.5 {lab=Vcon}
N -315 502.5 -315 527.5 {lab=Vcon}
N -400 550 -315 550 {lab=Vcon}
N -315 525 -315 550 {lab=Vcon}
N 1095 192.5 1095 867.5 {lab=VCO}
C {DLATCH.sym} -1980 380 0 0 {name=X5}
C {DLATCH.sym} -1980 730 0 0 {name=X6}
C {NAND2.sym} -1630 570 2 0 {name=X7}
C {INV.sym} -1330 370 0 0 {name=X8}
C {sky130_fd_pr/pfet_01v8.sym} -1080 370 0 0 {name=M29
W=1.5
L=0.6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -1080 720 0 0 {name=M30
W=1.5
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {vdd.sym} -1970 330 0 0 {name=l25 lab=VDD}
C {vdd.sym} -1285 335 0 0 {name=l37 lab=VDD}
C {vdd.sym} -1060 322.5 0 0 {name=l38 lab=VDD}
C {vdd.sym} -1970 680 0 0 {name=l39 lab=VDD}
C {vdd.sym} -1620 630 2 0 {name=l40 lab=VDD}
C {gnd.sym} -1060 765 0 0 {name=l41 lab=GND}
C {gnd.sym} -1620 490 2 0 {name=l42 lab=GND}
C {gnd.sym} -1970 470 0 0 {name=l43 lab=GND}
C {gnd.sym} -1285 402.5 0 0 {name=l44 lab=GND}
C {NAND8.sym} 2411.25 -580 0 0 {name=X9}
C {XNOR.sym} 2541.25 -100 3 0 {name=X25}
C {XNOR.sym} 2751.25 -100 3 0 {name=X26}
C {XNOR.sym} 2961.25 -100 3 0 {name=X27}
C {XNOR.sym} 3181.25 -100 3 0 {name=X28}
C {XNOR.sym} 2341.25 -100 3 0 {name=X29}
C {XNOR.sym} 2131.25 -100 3 0 {name=X30}
C {XNOR.sym} 1901.25 -100 3 0 {name=X31}
C {XNOR.sym} 3421.25 -100 3 0 {name=X32}
C {8_bit_synch_counter.sym} 1846.25 1025 0 0 {name=X33}
C {ipin.sym} 3311.25 885 3 0 {name=p8 lab=n0}
C {ipin.sym} 3351.25 885 3 0 {name=p9 lab=n1
}
C {ipin.sym} 3391.25 885 3 0 {name=p10 lab=n2}
C {ipin.sym} 3431.25 885 3 0 {name=p11 lab=n3}
C {ipin.sym} 3471.25 885 3 0 {name=p12 lab=n4}
C {ipin.sym} 3511.25 885 3 0 {name=p13 lab=n5}
C {ipin.sym} 3551.25 885 3 0 {name=p14 lab=n6}
C {ipin.sym} 3596.25 885 3 0 {name=p15 lab=n7}
C {INV.sym} 2631.25 -1055 3 0 {name=X34}
C {INV.sym} 1471.25 150 1 0 {name=X35}
C {INV.sym} 1471.25 395 1 0 {name=X36}
C {INV.sym} 1471.25 630 1 0 {name=X37}
C {vdd.sym} 2421.25 -700 3 0 {name=l45 lab=VDD}
C {vdd.sym} 2596.25 -1100 3 0 {name=l46 lab=VDD}
C {vdd.sym} 1506.25 195 1 0 {name=l47 lab=VDD}
C {vdd.sym} 1506.25 440 1 0 {name=l65 lab=VDD}
C {vdd.sym} 1506.25 675 1 0 {name=l69 lab=VDD}
C {vdd.sym} 1766.25 1085 3 0 {name=l70 lab=VDD}
C {gnd.sym} 1438.75 195 1 0 {name=l71 lab=GND}
C {gnd.sym} 1438.75 440 1 0 {name=l72 lab=GND}
C {gnd.sym} 1438.75 675 1 0 {name=l73 lab=GND}
C {gnd.sym} 2841.25 -700 3 0 {name=l74 lab=GND}
C {gnd.sym} 2663.75 -1100 3 0 {name=l75 lab=GND}
C {gnd.sym} 2596.25 1085 3 0 {name=l76 lab=GND}
C {vdd.sym} 1866.25 -100 3 0 {name=l77 lab=VDD}
C {gnd.sym} 2006.25 -100 3 0 {name=l78 lab=GND}
C {vdd.sym} 2096.25 -100 3 0 {name=l79 lab=VDD}
C {gnd.sym} 2236.25 -100 3 0 {name=l80 lab=GND}
C {vdd.sym} 2306.25 -100 3 0 {name=l81 lab=VDD}
C {gnd.sym} 2446.25 -100 3 0 {name=l82 lab=GND}
C {vdd.sym} 2506.25 -100 3 0 {name=l83 lab=VDD}
C {gnd.sym} 2646.25 -100 3 0 {name=l84 lab=GND}
C {vdd.sym} 2716.25 -100 3 0 {name=l85 lab=VDD}
C {gnd.sym} 2856.25 -100 3 0 {name=l86 lab=GND}
C {vdd.sym} 2926.25 -100 3 0 {name=l87 lab=VDD}
C {gnd.sym} 3066.25 -100 3 0 {name=l88 lab=GND}
C {vdd.sym} 3146.25 -100 3 0 {name=l89 lab=VDD}
C {gnd.sym} 3286.25 -100 3 0 {name=l90 lab=GND}
C {vdd.sym} 3386.25 -100 3 0 {name=l91 lab=VDD}
C {gnd.sym} 3526.25 -100 3 0 {name=l92 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1060 1750 0 0 {name=M31
W=1.5
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1060 1610 0 0 {name=M32
W=3
L=0.6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1220 1750 0 0 {name=M33
W=1.5
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1220 1610 0 0 {name=M34
W=3
L=0.6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 1180 1530 0 0 {name=l93 lab=VDD}
C {gnd.sym} 1176.25 1805 0 0 {name=l94 lab=GND
L=1.1
W=1.5}
C {ipin.sym} -2070 400 0 0 {name=p3 lab=Data}
C {opin.sym} 2510 1680 0 0 {name=p6 lab=Out}
C {opin.sym} 1220 1240 0 0 {name=p5 lab=VCO}
C {opin.sym} -520 550 3 0 {name=p4 lab=Vcon}
C {opin.sym} 2631.25 -1660 3 0 {name=p7 lab=FD}
C {gnd.sym} -620 650 0 0 {name=l95 lab=GND}
C {capa.sym} -620 620 0 0 {name=C51
m=1
value=50p
footprint=1206
device="ceramic capacitor"}
C {res.sym} -710 550 3 0 {name=R2
value=1k
footprint=1206
device=resistor
m=1}
C {sky130_fd_pr/pfet_01v8.sym} 85 -27.5 0 0 {name=M35
W=3
L=0.6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 85 112.5 0 0 {name=M36
W=3
L=3.39
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 85 270 0 0 {name=M37
W=1.5
L=3.39
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 85 390 0 0 {name=M38
W=1.5
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {vdd.sym} 105 -87.5 0 0 {name=l98 lab=VDD}
C {gnd.sym} 105 452.5 0 0 {name=l99 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 305 -27.5 0 0 {name=M39
W=3
L=0.6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 305 112.5 0 0 {name=M40
W=3
L=3.39
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 305 270 0 0 {name=M41
W=1.5
L=3.39
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 305 390 0 0 {name=M42
W=1.5
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {vdd.sym} 325 -87.5 0 0 {name=l100 lab=VDD}
C {gnd.sym} 325 452.5 0 0 {name=l101 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 525 -27.5 0 0 {name=M43
W=3
L=0.6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 525 112.5 0 0 {name=M44
W=3
L=3.39
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 525 270 0 0 {name=M45
W=1.5
L=3.39
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 525 390 0 0 {name=M46
W=1.5
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {vdd.sym} 545 -87.5 0 0 {name=l102 lab=VDD}
C {gnd.sym} 545 452.5 0 0 {name=l103 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 735 -27.5 0 0 {name=M47
W=3
L=0.6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 735 112.5 0 0 {name=M48
W=3
L=3.39
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 735 270 0 0 {name=M49
W=1.5
L=3.39
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 735 390 0 0 {name=M50
W=1.5
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {vdd.sym} 755 -87.5 0 0 {name=l104 lab=VDD}
C {gnd.sym} 755 452.5 0 0 {name=l105 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 955 -27.5 0 0 {name=M51
W=3
L=0.6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 955 112.5 0 0 {name=M52
W=3
L=3.39
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 955 270 0 0 {name=M53
W=1.5
L=3.39
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 955 390 0 0 {name=M54
W=1.5
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {vdd.sym} 975 -87.5 0 0 {name=l106 lab=VDD}
C {gnd.sym} 975 452.5 0 0 {name=l107 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} -105 392.5 0 0 {name=M55
W=1.5
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -105 -27.5 0 0 {name=M56
W=1.5
L=0.6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} -85 422.5 0 0 {name=l108 lab=GND}
C {vdd.sym} -85 -57.5 0 0 {name=l109 lab=VDD}
C {iopin.sym} -2370 322.5 3 0 {name=p1 lab=VDD}
C {iopin.sym} -1970 820 1 0 {name=p2 lab=GND}
